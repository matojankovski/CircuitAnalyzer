I1 0 1 1
R1 1 0 10k
R2 1 2 2k
V1 1 2 10
R3 2 0 1k

.op
