V1 1 0 5
R2 2 0 1k
R1 1 2 2k
V2 2 0 2

.op
