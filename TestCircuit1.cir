V3 1 1 20
R4 1 2 10k
R1 2 0 10k
V1 2 3 5
R3 3 0 10k
R2 3 4 10k
V2 4 0 10
.op
