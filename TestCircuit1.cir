V1 1 0 5
R1 1 2 1k
R2 2 0 1k
R3 2 3 1k
V2 3 0 2

.op
