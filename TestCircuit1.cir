V1 1 0 10
R1 1 2 2k
R3 2 0 8k
R2 2 3 4k
V2 3 0 20

.op
