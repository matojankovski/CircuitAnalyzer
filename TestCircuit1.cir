V1 2 1 32
R1 1 0 0.5k
R3 2 0 8k
R2 3 2 4.5k
V2 3 0 20
.op
