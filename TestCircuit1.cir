V1 1 0 5
R2 2 0 2k
R1 1 2 1k

.op
