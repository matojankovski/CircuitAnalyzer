V1 1 0 5
R2 1 2 10k
R1 2 0 10k
V1 2 0 20

.op
