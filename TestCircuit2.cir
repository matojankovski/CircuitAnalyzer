V1 1 0 10
R1 1 2 10k
R2 2 0 1k
R6 2 0 1k
R3 2 3 2k
R4 3 4 2k
R5 4 0 1k
R7 4 5 0.5k
V2 4 0 5
V3 5 0 1
.op
