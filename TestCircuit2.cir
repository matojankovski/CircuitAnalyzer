V1 5 0 5
R2 1 2 10k
R1 2 0 10k
V2 1 0 10

.op
